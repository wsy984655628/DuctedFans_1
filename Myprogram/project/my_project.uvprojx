# Keil uVision project my_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F427_437xx
  c include: ..\program\drivers;..\program;..\libraries\CMSIS;..\libraries\Drivers\src;..\libraries\Drivers\inc;..\program\mavlink;..\program\mavlink\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../libraries/CMSIS/: startup_stm32f427xx.s
  group CMSIS
    ../libraries/CMSIS/: system_stm32f4xx.c
    ../program/: stm32f4xx_conf.h
    ../libraries/Drivers/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group Drivers
    ../program/drivers/: led.c led.h usart.c usart.h pwm.c pwm.h receive.c receive.h at25512.c at25512.h w25q16.c w25q16.h mpu9250.c mpu9250.h ms5803.c ms5803.h MavlinkProtocol.c MavlinkProtocol.h
  group Program
    ../program/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h
  group Mavlink
    ../program/mavlink/common/: common.h mavlink.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_auth_key.h mavlink_msg_battery_status.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_command_ack.h mavlink_msg_command_long.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_encapsulated_data.h mavlink_msg_file_transfer_dir_list.h mavlink_msg_file_transfer_res.h mavlink_msg_file_transfer_start.h mavlink_msg_global_position_int.h mavlink_msg_global_position_setpoint_int.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_heartbeat.h mavlink_msg_highres_imu.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_local_position_setpoint.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_omnidirectional_flow.h mavlink_msg_optical_flow.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_roll_pitch_yaw_rates_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_speed_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_thrust_setpoint.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_pressure.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_global_position_setpoint_int.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_local_position_setpoint.h mavlink_msg_set_mode.h mavlink_msg_set_quad_motors_setpoint.h mavlink_msg_set_quad_swarm_led_roll_pitch_yaw_thrust.h mavlink_msg_set_quad_swarm_roll_pitch_yaw_thrust.h mavlink_msg_set_roll_pitch_yaw_speed_thrust.h mavlink_msg_set_roll_pitch_yaw_thrust.h mavlink_msg_setpoint_6dof.h mavlink_msg_setpoint_8dof.h mavlink_msg_sim_state.h mavlink_msg_state_correction.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_vfr_hud.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h testsuite.h version.h
    ../program/mavlink/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h
